# Keil uVision project STC15W204S_Bento.uvproj, settings and files
target STC15W204S_Bento (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC15W204S_Bento +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP.A51
  group App
    ./app/: main.c API_Bento.c
  group Driver
    ./driver/: board.c timer.c uart1.c
